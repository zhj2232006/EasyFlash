# IAR project EasyFlash.ewp, settings and files
configuration stm32f103xE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\app\inc; ..\components\others; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS_EWARM\Include; ..\Libraries\CMSIS_EWARM\CM3\DeviceSupport\ST\STM32F10x; ..\components\easyflash\inc; ..\..\..\..\..\easyflash\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EasyFlash.bin
  ILINK.IlinkOutputFile: EasyFlash.out
  ILINK.IlinkIcfFile: ..\components\others\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration stm32f103xB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; xUSE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 2
  ILINK.IlinkIcfFile: ..\components\others\stm32f103xB.icf
  group app
    ../app/src/: app.c stm32f10x_it.c
  group components/easyflash/port
    ../components/easyflash/port/: ef_port.c
  group components/easyflash/src
    ../../../../../easyflash/src/: easyflash.c ef_env.c ef_iap.c ef_utils.c
  group components/others
    ../components/others/: bsp.c
  group libs/cmsis
    ../Libraries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libs/std_periph_driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
